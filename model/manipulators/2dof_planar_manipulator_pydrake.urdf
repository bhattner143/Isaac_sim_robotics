Commit message: added a drake version of the code

File: model/manipulators/2dof_planar_manipulator_pydrake.urdf (robot description, URDF)
Before this commit: robot 2dof_planar_manipulator, 7 links, 6 joints
Joints:
- joint mount_box_joint: origin xyz=0 0 0 rpy=0 0 0 -> xyz=-3 0 0 rpy=0 0 0
